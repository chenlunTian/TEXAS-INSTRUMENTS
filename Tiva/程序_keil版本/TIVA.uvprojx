# Keil uVision project TIVA.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIVA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: .\Libraries\driverlib;.\Libraries\inc;.\Libraries\utils;.\User;.\WP_Ctrl;.\WP_Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Driverlib
    ./Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ./User/: Headfile.h main.c startup_rvmdk.S
    ./Libraries/utils/: uartstdio.c
  group Src
    ./WP_Src/: Time.c TimerConfigure.c Ringbuf.c ADCConfigure.c UartConfigure.c myiic.c Soft_I2C.c Key.c LED.c systems.c SPI.c PWMConfigure.c InterruptConfigure.c
software components: CMSIS Driver:I2C:Custom 2.3.0, CMSIS Driver:SPI:Custom 2.2.0, CMSIS Driver:USART:Custom 2.3.0
